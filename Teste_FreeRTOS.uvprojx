# Keil uVision project Teste_FreeRTOS.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Teste_FreeRTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\ArquivosLaunchPad\Config;.\ArquivosLaunchPad\Source\ARM_CM4F;.\ArquivosLaunchPad\Source\include;.\ArquivosLaunchPad\Biblioteca
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c
    ./ArquivosLaunchPad/Biblioteca/: ADCSWTrigger.c Nokia5110.c telas.c UART.c UART2.c bluetooth.c SysTick.c dht11.c io.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
